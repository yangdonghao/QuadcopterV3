# Keil uVision project Quadcopter.uvprojx, settings and files
target Quadcopter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Quadcopter
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MPU9150,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,EMPL_TARGET_STM32F4
  c misc: --C99 --wchar32
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  .\RTE\Device\eMPL\driver\STM32F4;  .\RTE\Device\eMPL\driver\eMPL;  .\RTE\Device\eMPL\driver\include;  .\RTE\Device\eMPL\eMPL-hal;  .\RTE\Device\eMPL\mllite;  .\RTE\Device\eMPL\mpl;  ../User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
  group Drivers/eMD
    ./RTE/Device/eMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./RTE/Device/eMPL/driver/STM32F4/: log_stm32.c mpu.c stm32f4xx_empl_drv.c
    ./RTE/Device/eMPL/eMPL-hal/: eMPL_outputs.c
    ./RTE/Device/eMPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./RTE/Device/eMPL/mpl/: libmpllib.a
  group Drives/others
    ../User/: LED_F4Discovery.c PWM_User.c
software components: CMSIS:CORE 4.1.0
